# Keil uVision project base_cm3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: base_cm3
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\library\CMSIS;..\library\FWlib\inc;..\FreeRTOS_v9\include;..\FreeRTOS_v9\port\RVDS\ARM_CM3;..\user;..\user\led;..\user\usart;..\user\dht11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../library/CMSIS/startup/: startup_stm32f10x_hd.s
  group cmsis
    ../library/CMSIS/: core_cm3.c system_stm32f10x.c
  group fwlib
    ../library/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: main.c stm32f10x_it.c
    ../user/led/: bsp_led.c
    ../user/usart/: bsp_usart.c
    ../user/dht11/: bsp_dht11.c
    ../user/i2c/: bsp_i2c_ee.c bsp_i2c_gpio.c
    ../user/flash/: bsp_spi_flash.c
    ../user/CRC16/: CRC16.c
    ../user/small_text_protocol/: stp.c
    ../user/GUI_APP/: gui_app.c
    ../user/sensors_APP/: sensors_app.c
    ../user/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
    ../user/nRF24L01/: 24L01.c
  group FreeRTOS/port
    ../FreeRTOS_v9/port/RVDS/ARM_CM3/: port.c
    ../FreeRTOS_v9/port/MemMang/: heap_4.c
  group FreeRTOS/src
    ../FreeRTOS_v9/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group lvgl
    ../library/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../library/GUI/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../library/GUI/lvgl/src/extra/: lv_extra.c
    ../library/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../library/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../library/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../library/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../library/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../library/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../library/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../library/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../library/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../library/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../library/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../library/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../library/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../library/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../library/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../library/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../library/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../library/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../library/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../library/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../library/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../library/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../library/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c warning_mark.c
    ../library/GUI/lvgl/src/gpu/: lv_gpu_stm32_dma2d.c
    ../library/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../library/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../library/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../library/GUI/: lv_port_disp.c lv_port_indev.c
